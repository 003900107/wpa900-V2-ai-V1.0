# IAR project Ai_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_HD; USE_FULL_ASSERT; USE_STDPERIPH_DRIVER; AI_SUBCORE; LXIV_POINT
  ICCARM.CCIncludePath2: ..\STM32F10x_StdPeriph_Driver\inc; ..\CMSIS; ..\user; ..\BSP; ..\DSPLIB_IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ai_test_V0.5.hex
  ILINK.IlinkOutputFile: Ai_test.out
  ILINK.IlinkIcfFile: generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group bsp
    ../BSP/: adc_calc.c BaseBus_Protocol.c bsp.c dft.c
  group cmsis
    ../CMSIS/: core_cm3.c
    ./: startup_stm32f10x_hd.s
  group fft
    ../DSPLIB_IAR/: cr4_fft_64_stm32.s stm32_dsp.h table_fft.h
  group std_periph_driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ../user/: main.c Realtimedb.c RTC_Time.c soe.c stm32f10x_conf.h stm32f10x_it.c system_stm32f10x.c
